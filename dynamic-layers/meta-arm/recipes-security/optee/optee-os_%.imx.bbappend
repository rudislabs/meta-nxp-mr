# NavQPlus uses mx8mpevk platform for OP-TEE
OPTEEMACHINE:imx8mpnavq = "imx-mx8mpevk"
